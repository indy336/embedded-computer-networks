<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>exercises</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>25000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\Listings\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>18</CpuCode>
<<<<<<< HEAD
      <Books>
        <Book>
          <Number>0</Number>
          <Title>STM32F746G-Discovery Quick Start Guide (STM32F746G-Discovery)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\Documentation\32F746GDISCOVERY_QSG.pdf</Path>
        </Book>
        <Book>
          <Number>1</Number>
          <Title>STM32F756G-Eval Quick Start Guide (STM32756G-EVAL)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\Documentation\STM32F756G-EVAL_QSG.pdf</Path>
        </Book>
        <Book>
          <Number>2</Number>
          <Title>BSP User Manual (STM32F746G-Discovery)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\Drivers\BSP\STM32746G-Discovery\STM32746G-Discovery_BSP_User_Manual.chm</Path>
        </Book>
        <Book>
          <Number>3</Number>
          <Title>BSP User Manual (STM32756G-EVAL)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\Drivers\BSP\STM32756G_EVAL\STM32756G_EVAL_BSP_User_Manual.chm</Path>
        </Book>
        <Book>
          <Number>4</Number>
          <Title>User Manual (STM32756G-EVAL)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32756G_EVAL\Documentation\DM00188617.pdf</Path>
        </Book>
        <Book>
          <Number>5</Number>
          <Title>Bill of Materials (STM32756G-EVAL)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32756G_EVAL\Documentation\stm327x6g-eval_bom.zip</Path>
        </Book>
        <Book>
          <Number>6</Number>
          <Title>Gerber Files (STM32756G-EVAL)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32756G_EVAL\Documentation\stm327x6g-eval_gerber.zip</Path>
        </Book>
        <Book>
          <Number>7</Number>
          <Title>Schematics (STM32756G-EVAL)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32756G_EVAL\Documentation\stm327x6g-eval_sch.zip</Path>
        </Book>
        <Book>
          <Number>8</Number>
          <Title>User Manual (STM32F746G-Discovery)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32F746G_Discovery\Documentation\DM00190424.pdf</Path>
        </Book>
        <Book>
          <Number>9</Number>
          <Title>Bill of Materials (STM32F746G-Discovery)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32F746G_Discovery\Documentation\stm32f746g-disco_bom.zip</Path>
        </Book>
        <Book>
          <Number>10</Number>
          <Title>Gerber Files (STM32F746G-Discovery)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32F746G_Discovery\Documentation\stm32f746g-disco_gerber.zip</Path>
        </Book>
        <Book>
          <Number>11</Number>
          <Title>Schematics (STM32F746G-Discovery)</Title>
          <Path>C:\Keil_v5\ARM\PACK\Keil\STM32F7xx_DFP\2.7.0\MDK\Boards\ST\STM32F746G_Discovery\Documentation\stm32f746g-disco_sch.zip</Path>
        </Book>
        <Book>
          <Number>12</Number>
          <Title>STM32756G_EVAL Evaluation Board Web Page (STM32756G-EVAL)</Title>
          <Path>http://www.st.com/web/catalog/tools/FM116/SC959/SS1532/LN1199/PF261640</Path>
        </Book>
        <Book>
          <Number>13</Number>
          <Title>STM32F746G_Discovery Web Page (STM32F746G-Discovery)</Title>
          <Path>http://www.st.com/web/catalog/tools/FM116/SC959/SS1532/LN1848/PF261641</Path>
        </Book>
      </Books>
=======
>>>>>>> upstream/master
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <nTsel>5</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>STLink\ST-LINKIII-KEIL_SWO.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)(1012=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 ) -FN1 -FC1000 -FD20010000 -FF0STM32F7x_1024 -FL0100000 -FS08000000 -FP0($$Device:STM32F746NGHx$CMSIS\Flash\STM32F7x_1024.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ST-LINKIII-KEIL_SWO</Key>
          <Name>-U0669FF525053885087043012 -O207 -S1 -C0 -A0 -N00("ARM CoreSight SW-DP") -D00(5BA02477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8004 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO7 -FD20000000 -FC1000 -FN2 -FF0STM32F7x_1024.FLM -FS08000000 -FL0100000 -FP0($$Device:STM32F746NGHx$CMSIS\Flash\STM32F7x_1024.FLM) -FF1STM32F7x_TCM.FLM -FS1200000 -FL1100000 -FP1($$Device:STM32F746NGHx$CMSIS\Flash\STM32F7x_TCM.FLM)</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
      <DebugDescription>
        <Enable>1</Enable>
        <EnableLog>0</EnableLog>
        <Protocol>2</Protocol>
        <DbgClock>10000000</DbgClock>
      </DebugDescription>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>application</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
      <PathWithFileName>..\src\b_led_dice.c</PathWithFileName>
      <FilenameWithoutPath>b_led_dice.c</FilenameWithoutPath>
=======
      <PathWithFileName>..\src\a_traffic_light.c</PathWithFileName>
      <FilenameWithoutPath>a_traffic_light.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\b_led_dice.c</PathWithFileName>
      <FilenameWithoutPath>b_led_dice.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\a_traffic_light_solution.c</PathWithFileName>
      <FilenameWithoutPath>a_traffic_light_solution.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\b_led_dice_solution.c</PathWithFileName>
      <FilenameWithoutPath>b_led_dice_solution.c</FilenameWithoutPath>
>>>>>>> upstream/master
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>configuration</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>2</FileNumber>
=======
      <FileNumber>5</FileNumber>
>>>>>>> upstream/master
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\startup_stm32f746xx.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f746xx.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>3</FileNumber>
=======
      <FileNumber>6</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\system_stm32f7xx.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f7xx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>4</FileNumber>
=======
      <FileNumber>7</FileNumber>
>>>>>>> upstream/master
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\inc\stm32f7xx_hal_conf.h</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_conf.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>5</FileNumber>
=======
      <FileNumber>8</FileNumber>
>>>>>>> upstream/master
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\inc\stm32f7xx_it.h</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_it.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>6</FileNumber>
=======
      <FileNumber>9</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\src\stm32f7xx_it.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_it.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>stm32f7xx_hal</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>7</FileNumber>
=======
      <FileNumber>10</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>8</FileNumber>
=======
      <FileNumber>11</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_adc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>9</FileNumber>
=======
      <FileNumber>12</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_adc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_adc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>10</FileNumber>
=======
      <FileNumber>13</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_can.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_can.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>11</FileNumber>
=======
      <FileNumber>14</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_cec.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_cec.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>12</FileNumber>
=======
      <FileNumber>15</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_cortex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_cortex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>13</FileNumber>
=======
      <FileNumber>16</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_crc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_crc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>14</FileNumber>
=======
      <FileNumber>17</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_crc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_crc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>15</FileNumber>
=======
      <FileNumber>18</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_cryp.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_cryp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>16</FileNumber>
=======
      <FileNumber>19</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_cryp_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_cryp_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>17</FileNumber>
=======
      <FileNumber>20</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dac.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dac.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>18</FileNumber>
=======
      <FileNumber>21</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dac_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dac_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>19</FileNumber>
=======
      <FileNumber>22</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dcmi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dcmi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>20</FileNumber>
=======
      <FileNumber>23</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dcmi_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dcmi_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>21</FileNumber>
=======
      <FileNumber>24</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dfsdm.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dfsdm.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>22</FileNumber>
=======
      <FileNumber>25</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>23</FileNumber>
=======
      <FileNumber>26</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dma_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dma_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>24</FileNumber>
=======
      <FileNumber>27</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dma2d.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dma2d.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>25</FileNumber>
=======
      <FileNumber>28</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_dsi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_dsi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>26</FileNumber>
=======
      <FileNumber>29</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_eth.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_eth.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>27</FileNumber>
=======
      <FileNumber>30</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_flash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_flash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>28</FileNumber>
=======
      <FileNumber>31</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_flash_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_flash_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>29</FileNumber>
=======
      <FileNumber>32</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>30</FileNumber>
=======
      <FileNumber>33</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_hash.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_hash.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>31</FileNumber>
=======
      <FileNumber>34</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_hash_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_hash_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>32</FileNumber>
=======
      <FileNumber>35</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_hcd.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_hcd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>33</FileNumber>
=======
      <FileNumber>36</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_i2c.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>34</FileNumber>
=======
      <FileNumber>37</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_i2c_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_i2c_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>35</FileNumber>
=======
      <FileNumber>38</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_i2s.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_i2s.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>36</FileNumber>
=======
      <FileNumber>39</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_irda.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_irda.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>37</FileNumber>
=======
      <FileNumber>40</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_iwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_iwdg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>38</FileNumber>
=======
      <FileNumber>41</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_jpeg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_jpeg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>39</FileNumber>
=======
      <FileNumber>42</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_lptim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_lptim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>40</FileNumber>
=======
      <FileNumber>43</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_ltdc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_ltdc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>41</FileNumber>
=======
      <FileNumber>44</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_ltdc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_ltdc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>42</FileNumber>
=======
      <FileNumber>45</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_mdios.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_mdios.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>43</FileNumber>
=======
      <FileNumber>46</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_mmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_mmc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>44</FileNumber>
=======
      <FileNumber>47</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_msp_template.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_msp_template.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>45</FileNumber>
=======
      <FileNumber>48</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_nand.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_nand.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>46</FileNumber>
=======
      <FileNumber>49</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_nor.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_nor.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>47</FileNumber>
=======
      <FileNumber>50</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_pcd.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_pcd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>48</FileNumber>
=======
      <FileNumber>51</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_pcd_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_pcd_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>49</FileNumber>
=======
      <FileNumber>52</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_pwr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>50</FileNumber>
=======
      <FileNumber>53</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_pwr_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_pwr_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>51</FileNumber>
=======
      <FileNumber>54</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_qspi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_qspi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>52</FileNumber>
=======
      <FileNumber>55</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>53</FileNumber>
=======
      <FileNumber>56</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_rcc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_rcc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>54</FileNumber>
=======
      <FileNumber>57</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_rng.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_rng.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>55</FileNumber>
=======
      <FileNumber>58</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_rtc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_rtc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>56</FileNumber>
=======
      <FileNumber>59</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_rtc_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_rtc_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>57</FileNumber>
=======
      <FileNumber>60</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_sai.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_sai.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>58</FileNumber>
=======
      <FileNumber>61</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_sai_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_sai_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>59</FileNumber>
=======
      <FileNumber>62</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_sd.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_sd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>60</FileNumber>
=======
      <FileNumber>63</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_sdram.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_sdram.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>61</FileNumber>
=======
      <FileNumber>64</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_smartcard.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_smartcard.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>62</FileNumber>
=======
      <FileNumber>65</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_smartcard_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_smartcard_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>63</FileNumber>
=======
      <FileNumber>66</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_smbus.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_smbus.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>64</FileNumber>
=======
      <FileNumber>67</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_spdifrx.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_spdifrx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>65</FileNumber>
=======
      <FileNumber>68</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_spi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>66</FileNumber>
=======
      <FileNumber>69</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_sram.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_sram.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>67</FileNumber>
=======
      <FileNumber>70</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>68</FileNumber>
=======
      <FileNumber>71</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_tim_ex.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_tim_ex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>69</FileNumber>
=======
      <FileNumber>72</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_uart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_uart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>70</FileNumber>
=======
      <FileNumber>73</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_usart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>71</FileNumber>
=======
      <FileNumber>74</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_hal_wwdg.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_hal_wwdg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>72</FileNumber>
=======
      <FileNumber>75</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_adc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_adc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>73</FileNumber>
=======
      <FileNumber>76</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_crc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_crc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>74</FileNumber>
=======
      <FileNumber>77</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_dac.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_dac.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>75</FileNumber>
=======
      <FileNumber>78</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_dma.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>76</FileNumber>
=======
      <FileNumber>79</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_dma2d.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_dma2d.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>77</FileNumber>
=======
      <FileNumber>80</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_exti.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_exti.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>78</FileNumber>
=======
      <FileNumber>81</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_fmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_fmc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>79</FileNumber>
=======
      <FileNumber>82</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>80</FileNumber>
=======
      <FileNumber>83</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_i2c.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>81</FileNumber>
=======
      <FileNumber>84</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_lptim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_lptim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>82</FileNumber>
=======
      <FileNumber>85</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_pwr.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_pwr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>83</FileNumber>
=======
      <FileNumber>86</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_rcc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>84</FileNumber>
=======
      <FileNumber>87</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_rng.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_rng.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>85</FileNumber>
=======
      <FileNumber>88</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_rtc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_rtc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>86</FileNumber>
=======
      <FileNumber>89</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_sdmmc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_sdmmc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>87</FileNumber>
=======
      <FileNumber>90</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_spi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>88</FileNumber>
=======
      <FileNumber>91</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_tim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>89</FileNumber>
=======
      <FileNumber>92</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_usart.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_usart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>90</FileNumber>
=======
      <FileNumber>93</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_usb.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_usb.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>91</FileNumber>
=======
      <FileNumber>94</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\stm32f7xx_hal\src\stm32f7xx_ll_utils.c</PathWithFileName>
      <FilenameWithoutPath>stm32f7xx_ll_utils.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>stm32f7_discovery_bsp_shu</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>92</FileNumber>
=======
      <FileNumber>95</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\bsp\stm32f7_discovery_shu_kit\src\clock.c</PathWithFileName>
      <FilenameWithoutPath>clock.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>93</FileNumber>
=======
      <FileNumber>96</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\bsp\stm32f7_discovery_shu_kit\src\gpio.c</PathWithFileName>
      <FilenameWithoutPath>gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>94</FileNumber>
=======
      <FileNumber>97</FileNumber>
>>>>>>> upstream/master
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\..\libraries\bsp\stm32f7_discovery_shu_kit\src\random_numbers.c</PathWithFileName>
      <FilenameWithoutPath>random_numbers.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

</ProjectOpt>
